# Keil uVision project Data_Acq.uvprojx, settings and files
target Data_Acq (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Data_Acq +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\STM32F10x_FWLib\inc;..\USER;..\CORE;..\HARDWARE\LED;..\Peripherals_Init;..\HARDWARE\NRF24L01;..\HARDWARE\DHT12;..\Gizwits;..\HARDWARE\KEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group Peripherals
    ../Peripherals_Init/: uart.c delay.c iic.c tim.c spi.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT12/: dht12.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/NRF24L01/: nrf24l01.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_gpio.c stm32f10x_exti.c
  group README
    ../: READMIN.txt
